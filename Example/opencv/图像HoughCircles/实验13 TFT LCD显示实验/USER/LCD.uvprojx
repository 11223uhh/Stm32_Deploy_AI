# Keil uVision project LCD.uvprojx, settings and files
target LCD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LCD +hex
  c flags: uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4 __FPU_PRESENT=1U
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\FWLIB\inc;..\CMSIS\NN\Include;..\CMSIS\DSP\Include;..\opencv\cv\include;..\opencv\cvaux\include;..\opencv\cxcore\include;..\MALLOC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: stm32f4xx_it.c system_stm32f4xx.c main.cpp bu.c
    ../MALLOC/: malloc.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group README
    ../: readme.txt
  group opencv
    ../opencv/cxcore/src/: cxarray.cpp cxalloc.cpp cxcopy.cpp cxerror.cpp cxdatastructs.cpp cxtables.cpp cxconvert.cpp cxlut.cpp cxmathfuncs.cpp cxarithm.cpp cxmatmul.cpp cxmatrix.cpp cxutils.cpp cxsvd.cpp cxminmaxloc.cpp cxnorm.cpp cxrand.cpp cxmean.cpp cxmeansdv.cpp cxdxt.cpp cxsumpixels.cpp cxdrawing.cpp cxouttext.cpp
    ../opencv/cv/src/: cvtables.cpp
  group opencv_test
    ../opencv/cv/src/: cvcolor.cpp cvimgwarp.cpp cvfilter.cpp cvtemplmatch.cpp cvutils.cpp cvaccum.cpp cvsumpixels.cpp cvcanny.cpp cvderiv.cpp cvhough.cpp
software components: CMSIS:CORE 5.1.2, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
