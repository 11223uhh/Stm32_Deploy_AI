# Keil uVision project LED.uvprojx, settings and files
target Target 1 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\CORE;..\third_party\flatbuffers\include;..\third_party\gemmlowp;..\third_party\ruy;..\..\das;..\FWLIB\inc;..\HARDWARE\LCD
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.cpp debug_log.c hello_world.lib model.cc stm32f4xx_it.c sine_model.cpp system_stm32f4xx.c
    ../CORE/: startup_stm32f40_41xxx.s
  group HARDWARE
    ../SYSTEM/delay/: delay.cpp
    ../HARDWARE/LED/: led.cpp
    ../SYSTEM/usart/: usart.c
    ../HARDWARE/LCD/: lcd.cpp
  group SYSTEM
    ../SYSTEM/sys/: sys.cpp
  group FWLib
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_fsmc.c
  group README
    ../: README.TXT
software components: CMSIS:CORE 5.1.2, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
